Commit message: backup before reinstalling ros

File: urdf/03_olaf.urdf (robot description, URDF)
Before this commit: robot olaf, 6 links, 5 joints
Links:
- removed link lidar_link
Joints:
- removed joint rostopic
